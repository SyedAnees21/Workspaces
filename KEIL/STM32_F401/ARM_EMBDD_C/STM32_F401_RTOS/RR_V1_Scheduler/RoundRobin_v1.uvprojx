# Keil uVision project RoundRobin_v1.uvprojx, settings and files
target stm32f4 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoundRobin_v1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group osKernel
    ./: osKernel.h osKernel.c osKernel.s
  group user
    ./: main.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.6.0
