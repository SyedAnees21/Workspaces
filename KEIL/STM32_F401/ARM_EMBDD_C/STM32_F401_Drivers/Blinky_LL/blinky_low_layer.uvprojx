# Keil uVision project blinky_low_layer.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky_low_layer
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F401CCUx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F401CCUx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 5.5.0, Device:STM32Cube LL:Common 1.7.13, Device:STM32Cube LL:GPIO 1.7.13, Device:STM32Cube LL:PWR 1.7.13, Device:STM32Cube LL:RCC 1.7.13, Device:STM32Cube LL:UTILS 1.7.13, Device:Startup 2.6.3
